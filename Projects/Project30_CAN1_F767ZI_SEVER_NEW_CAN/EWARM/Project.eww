<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Project30_CAN1_F767ZI_SEVER_NEW_CAN.ewp</path>
  </project>
  <batchBuild />
</workspace>
