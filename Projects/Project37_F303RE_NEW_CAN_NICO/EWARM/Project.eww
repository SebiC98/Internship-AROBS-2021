<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Project37_F303RE_NEW_CAN_NICO.ewp</path>
  </project>
  <batchBuild />
</workspace>
