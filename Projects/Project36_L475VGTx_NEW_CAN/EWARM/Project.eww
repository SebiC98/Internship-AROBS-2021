<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Project36_L475VGTx_NEW_CAN.ewp</path>
  </project>
  <batchBuild />
</workspace>
