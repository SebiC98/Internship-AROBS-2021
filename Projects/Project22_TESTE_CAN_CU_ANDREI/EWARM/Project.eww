<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Project22_TESTE_CAN_CU_ANDREI.ewp</path>
  </project>
  <batchBuild />
</workspace>
