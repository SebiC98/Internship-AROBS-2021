<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Project32_F767ZI_CAN1_NEW_HAL.ewp</path>
  </project>
  <batchBuild />
</workspace>
