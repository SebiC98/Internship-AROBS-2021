<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Project8_RECEIVE_DATA_USART.ewp</path>
  </project>
  <batchBuild />
</workspace>
