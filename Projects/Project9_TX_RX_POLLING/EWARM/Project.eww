<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Project9_TX_RX_POLLING.ewp</path>
  </project>
  <batchBuild />
</workspace>
