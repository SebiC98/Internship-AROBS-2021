<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Project5_HCSR04_ControllersTech.ewp</path>
  </project>
  <batchBuild />
</workspace>
