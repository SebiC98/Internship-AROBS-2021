<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Project2_PWM_LED2.ewp</path>
  </project>
  <batchBuild />
</workspace>
