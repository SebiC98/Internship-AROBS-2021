<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Project13_I2C_cu_Andrei.ewp</path>
  </project>
  <batchBuild />
</workspace>
