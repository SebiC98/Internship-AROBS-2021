<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Project38_F767ZI_CAN1_CAN3_SIGNAL_ROUTING.ewp</path>
  </project>
  <batchBuild />
</workspace>
