<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Project20_CAN_F767ZI_SEVER_OLD_CAN_LED_BUTTON.ewp</path>
  </project>
  <batchBuild />
</workspace>
