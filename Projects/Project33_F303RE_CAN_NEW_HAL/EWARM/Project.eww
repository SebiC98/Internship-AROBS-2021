<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Project33_F303RE_CAN_NEW_HAL.ewp</path>
  </project>
  <batchBuild />
</workspace>
