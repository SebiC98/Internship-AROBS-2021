<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Project5_HCSR04_2PM.ewp</path>
  </project>
  <batchBuild />
</workspace>
