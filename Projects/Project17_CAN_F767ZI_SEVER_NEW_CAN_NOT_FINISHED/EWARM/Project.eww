<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Project17_CAN_F767ZI.ewp</path>
  </project>
  <batchBuild />
</workspace>
