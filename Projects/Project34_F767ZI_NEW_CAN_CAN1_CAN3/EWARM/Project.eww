<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Project34_F767ZI_NEW_CAN_CAN1_CAN3.ewp</path>
  </project>
  <batchBuild />
</workspace>
