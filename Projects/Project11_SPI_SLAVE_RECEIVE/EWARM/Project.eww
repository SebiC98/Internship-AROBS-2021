<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Project11_SPI_SLAVE_RECEIVE.ewp</path>
  </project>
  <batchBuild />
</workspace>
