<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Project5_HCS04_FaraEcho.ewp</path>
  </project>
  <batchBuild />
</workspace>
