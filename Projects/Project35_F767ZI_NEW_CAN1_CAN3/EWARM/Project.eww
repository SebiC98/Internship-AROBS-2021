<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Project35_F767ZI_NEW_CAN1.ewp</path>
  </project>
  <batchBuild />
</workspace>
