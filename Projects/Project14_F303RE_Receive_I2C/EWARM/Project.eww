<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Project14_F303RE_Receive_I2C.ewp</path>
  </project>
  <batchBuild />
</workspace>
