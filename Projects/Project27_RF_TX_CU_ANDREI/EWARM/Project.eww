<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Project27_RF_TX_CU_ANDREI.ewp</path>
  </project>
  <batchBuild />
</workspace>
