<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Project10_I2C.ewp</path>
  </project>
  <batchBuild />
</workspace>
