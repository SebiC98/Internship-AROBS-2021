<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Project25_TEST_RF_USART2.ewp</path>
  </project>
  <batchBuild />
</workspace>
