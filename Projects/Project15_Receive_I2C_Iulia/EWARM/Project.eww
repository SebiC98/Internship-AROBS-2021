<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Project15_Receive_I2C_Iulia.ewp</path>
  </project>
  <batchBuild />
</workspace>
