<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Project7_SEND_DATA_USART.ewp</path>
  </project>
  <batchBuild />
</workspace>
