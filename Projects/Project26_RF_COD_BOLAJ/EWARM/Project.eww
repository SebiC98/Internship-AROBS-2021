<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Project26_RF_COD_BOLAJ.ewp</path>
  </project>
  <batchBuild />
</workspace>
