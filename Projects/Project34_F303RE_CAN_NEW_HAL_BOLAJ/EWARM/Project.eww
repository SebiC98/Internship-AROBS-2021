<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Project34_F303RE_CAN_NEW_HAL_BOLAJ.ewp</path>
  </project>
  <batchBuild />
</workspace>
