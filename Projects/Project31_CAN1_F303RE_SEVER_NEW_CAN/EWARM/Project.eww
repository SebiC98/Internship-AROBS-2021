<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Project31_CAN1_F303RE_SEVER_NEW_CAN.ewp</path>
  </project>
  <batchBuild />
</workspace>
